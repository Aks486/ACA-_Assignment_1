;Consider a 32-bit number present in 0x40000000.Find the number of ones and zero present in the 32-bit number.Store the result in 0x40000004 and 0x40000008
	AREA ZEROANDONES, CODE, READONLY
	ENTRY
MAIN
	LDR R1,=0X40000000 ;LOAD THE ADDRESS LOCATION
	LDR R1,[R1] ;LOAD THE 32-BIT NUMBER TO THE REGISTER R1
	MOV R0,#1 ;INCREMENT R0 BY 1
	MOV R5,#0 ;LOOP INDEX
CHECK
	CMP R5,#32	;
	BEQ DONE ;BRANCH TO DONE IF EQUAL
	ANDS R2,R1,R0 ;AND R1 WITH R0 WITH CARRY AND STORE RESULT IN R2 
	BNE ONE ;BRANCH TO ONE IF NOT EQUAL
	ADD R7,#1 ; ADD 1 TO R7
	ADD R5,#1 ;INCREMENT THE LOOP INDEX
	MOV R0,R0,LSL #1 ;LOGICAL LEFT-SHIFT CONTENTS IN R0 BY 1-BIT
	B CHECK ;RUN THE LOOP AGAIN 
ONE	ADD R6,#1 ;INCREMENT R6 BY 1
	ADD R5,#1 ;INCREMENT R5 BY 1
	MOV R0,R0,LSL #1 ;LOGICAL LEFT-SHIFT CONTENTS IN R0 AND MOVE IT BACK TO R0
	B CHECK

DONE
	LDR R8,=0X40000004 ;LOAD THE ADDRESS
	STR R6,[R8] ;STORE THE RESULT
	LDR R8,=0X40000008 ;LOAD THE ADDRESS
	STR R7,[R8] ;STORE THE RESULT
STOP B STOP	
	END
